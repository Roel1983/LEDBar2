File: Devices/LedBar/Hardware/Boards/MainBoard/MainBoard.kicad_pcb (KiCad board)
At the start: 2 copper layers, 120 x 24 mm, 0 parts

Commit message: Placed components for RS485
Parts:
- added C301: 0.1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, B.Cu at (109.5, 112.6)
- added C302: 10uF, Capacitor_Tantalum_SMD:CP_EIA-3216-18_Kemet-A_Pad1.58x1.35mm_HandSolder, F.Cu at (109.7, 113.0)
- added C303: 4.7uF, Capacitor_Tantalum_SMD:CP_EIA-3216-18_Kemet-A_Pad1.58x1.35mm_HandSolder, F.Cu at (124.0, 113.0)
- added C304: 0.1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, B.Cu at (124.3, 113.8)
- added D301: PSM712, Package_TO_SOT_SMD:SOT-23_Handsoldering, B.Cu at (109.5, 118.6)
- added F201: Max. 5A F, AmbientLight:Fuseholder_Cylinder-5x20mm_BLX_A_Horizontal, F.Cu at (132.7, 105.5)
- added J201: 12VDC/5A, AmbientLight:15EDGRC-3.81-2P, F.Cu at (105.9, 107.2)
- added J301: RS485, AmbientLight:15EDGRC-3.5-3P, F.Cu at (105.9, 120.2)
- added J601: 0-10V(1), AmbientLight:15EDGRC-3.5-2P, F.Cu at (214.0, 112.5)
- added J602: 0-10V(2), AmbientLight:15EDGRC-3.5-2P, F.Cu at (214.0, 103.2)
- added R301: 120, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, B.Cu at (109.4, 114.8)
- added R302: 120, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, B.Cu at (109.5, 122.4)
- added TP201: gnd, AmbientLight:TestPoint_Pad_D1.0mm, F.Cu at (103.3, 107.2)
- added TP301: B, AmbientLight:TestPoint_Pad_D1.0mm, F.Cu at (103.3, 114.8)
- added TP302: A, AmbientLight:TestPoint_Pad_D1.0mm, F.Cu at (103.3, 117.5)
- added TP303: +5V_iso, AmbientLight:TestPoint_Pad_D1.0mm, F.Cu at (103.3, 112.1)
- added TP304: GND_iso, AmbientLight:TestPoint_Pad_D1.0mm, F.Cu at (103.3, 120.1)
- added TP305: txd, AmbientLight:TestPoint_Pad_D1.0mm, F.Cu at (124.3, 122.0)
- added TP306: rxd, AmbientLight:TestPoint_Pad_D1.0mm, F.Cu at (124.3, 117.0)
- added TP307: tx_en, AmbientLight:TestPoint_Pad_D1.0mm, F.Cu at (124.3, 119.5)
- added U301: ISO3082DW, Package_SO:SOIC-16W_7.5x10.3mm_P1.27mm, B.Cu at (117.3, 118.1)
- added U302: B0505S-1W-SIP4, AmbientLight:B0505S-1W, F.Cu at (120.7, 111.6)
Routing:
- net GND_iso: track 0.00 -> 74.5 mm
- net +5V_iso: track 0.00 -> 18.4 mm
- net +5V: track 0.00 -> 14.5 mm
- net Net-(D301-Pad1): track 0.00 -> 8.83 mm
- net Net-(D301-Pad2): track 0.00 -> 8.75 mm
- net GND: track 0.00 -> 5.70 mm
- net Net-(R302-Pad2): track 0.00 -> 5.20 mm
- net Net-(R301-Pad2): track 0.00 -> 4.56 mm
- net /Microcontroller/tx_en: track 0.00 -> 3.92 mm
- net /Microcontroller/txd: track 0.00 -> 3.59 mm
- net GNDPWR: track 0.00 -> 2.67 mm
- net /Microcontroller/rxd: track 0.00 -> 2.65 mm

Commit message: Placing and routing
Parts:
- removed J602: 0-10V(2), AmbientLight:15EDGRC-3.5-2P
- added C205: 10uF/16V, Capacitor_Tantalum_SMD:CP_EIA-6032-28_Kemet-C_Pad2.25x2.35mm_HandSolder, B.Cu at (122.8, 105.6)
- added C206: 0.1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, B.Cu at (125.7, 103.6)
- added C502: 0.1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, B.Cu at (181.1, 105.7)
- added C503: 1000uF/16V, Capacitor_THT:CP_Radial_D10.0mm_P5.00mm, F.Cu at (181.1, 103.3)
- added C504: 0.1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, B.Cu at (165.5, 105.7)
- added C505: 1000uF/16V, Capacitor_THT:CP_Radial_D10.0mm_P5.00mm, F.Cu at (165.5, 103.3)
- added C601: 1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (238.4, 121.0)
- added C602: 1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (240.4, 121.0)
- added C603: 0.1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, B.Cu at (253.1, 103.1)
- added C604: 0.1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, B.Cu at (253.1, 106.3)
- added C605: 0.1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (249.3, 116.3)
- added C606: 4.7uF/16V, Capacitor_Tantalum_SMD:CP_EIA-6032-28_Kemet-C_Pad2.25x2.35mm_HandSolder, F.Cu at (245.7, 111.0)
- added D201: SMBJ15A, Diode_SMD:D_SMB_Handsoldering, F.Cu at (139.2, 105.3)
- added D401: Green, LED_SMD:LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder, F.Cu at (109.6, 122.1)
- added D402: Yellow, LED_SMD:LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder, F.Cu at (113.3, 122.1)
- added D403: Orange, LED_SMD:LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder, F.Cu at (117.1, 122.1)
- added D404: Red, LED_SMD:LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder, F.Cu at (120.9, 122.1)
- added J501: Left, Connector_PinHeader_2.00mm:PinHeader_1x05_P2.00mm_Vertical, B.Cu at (191.9, 105.2)
- added J502: Center, Connector_PinSocket_2.00mm:PinSocket_2x07_P2.00mm_Vertical, B.Cu at (172.3, 104.8)
- added J503: Right, Connector_PinHeader_2.00mm:PinHeader_1x05_P2.00mm_Vertical, B.Cu at (155.2, 104.3)
- added JP401: SolderJumper_2_Open, Jumper:SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm, F.Cu at (116.6, 118.7)
- added JP402: SolderJumper_2_Open, Jumper:SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm, F.Cu at (119.2, 118.7)
- added JP403: SolderJumper_2_Open, Jumper:SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm, F.Cu at (111.6, 118.7)
- added JP404: SolderJumper_2_Open, Jumper:SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm, F.Cu at (109.0, 118.7)
- added JP405: SolderJumper_2_Open, Jumper:SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm, F.Cu at (114.1, 118.7)
- added NT201: Net-Tie_2, NetTie:NetTie-2_SMD_Pad0.5mm, F.Cu at (147.3, 110.6)
- added Q501: Si2302DS, Package_TO_SOT_SMD:SOT-23_Handsoldering, B.Cu at (184.2, 110.5)
- added Q502: Si2302DS, Package_TO_SOT_SMD:SOT-23_Handsoldering, B.Cu at (178.2, 110.4)
- added Q503: Si2302DS, Package_TO_SOT_SMD:SOT-23_Handsoldering, B.Cu at (168.5, 110.4)
- added Q504: Si2302DS, Package_TO_SOT_SMD:SOT-23_Handsoldering, B.Cu at (162.4, 110.4)
- added Q505: Si2302DS, Package_TO_SOT_SMD:SOT-23_Handsoldering, B.Cu at (184.2, 105.0)
- added Q506: Si2302DS, Package_TO_SOT_SMD:SOT-23_Handsoldering, B.Cu at (178.2, 104.9)
- added Q507: Si2302DS, Package_TO_SOT_SMD:SOT-23_Handsoldering, B.Cu at (168.5, 104.9)
- added Q508: Si2302DS, Package_TO_SOT_SMD:SOT-23_Handsoldering, B.Cu at (162.4, 104.9)
- added Q509: Si2302DS, Package_TO_SOT_SMD:SOT-23_Handsoldering, B.Cu at (184.3, 115.8)
- added Q510: Si2302DS, Package_TO_SOT_SMD:SOT-23_Handsoldering, B.Cu at (178.8, 115.8)
- added Q511: Si2302DS, Package_TO_SOT_SMD:SOT-23_Handsoldering, B.Cu at (167.9, 115.8)
- added Q512: Si2302DS, Package_TO_SOT_SMD:SOT-23_Handsoldering, B.Cu at (162.4, 115.8)
- added Q513: Si2302DS, Package_TO_SOT_SMD:SOT-23_Handsoldering, B.Cu at (184.3, 119.4)
- added Q514: Si2302DS, Package_TO_SOT_SMD:SOT-23_Handsoldering, B.Cu at (178.8, 119.4)
- added Q515: Si2302DS, Package_TO_SOT_SMD:SOT-23_Handsoldering, B.Cu at (167.9, 119.4)
- added Q516: Si2302DS, Package_TO_SOT_SMD:SOT-23_Handsoldering, B.Cu at (162.4, 119.4)
- added R204: 100R/1W, Resistor_SMD:R_1812_4532Metric_Pad1.30x3.40mm_HandSolder, B.Cu at (127.8, 107.4)
- added R601: 100k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, B.Cu at (214.8, 138.7)
- added R602: 100k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, B.Cu at (212.7, 148.6)
- added R603: 1k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (245.4, 116.3)
- added R604: 10k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (242.4, 117.2)
- added R605: 10k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (242.6, 121.0)
- added R606: 1k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (253.1, 117.5)
- added R607: 10k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (253.1, 120.0)
- added R608: 10k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (253.1, 121.9)
- added R609: 100, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (242.4, 104.1)
- added RN401: 10k, Resistor_SMD:R_Array_Concave_4x0603, F.Cu at (122.7, 119.3)
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Connections:
- J601 pad 2: GND -> Net-(C604-Pad1)
Routing:
- net GND: track 5.70 -> 150.3 mm, vias 0 -> 2
- net Net-(C603-Pad1): track 0.00 -> 32.2 mm
- net Net-(C604-Pad1): track 0.00 -> 28.7 mm
- net +12VA: track 0.00 -> 26.5 mm
- net +5V: track 14.5 -> 31.8 mm
- net /Microcontroller/addr4: track 0.00 -> 13.7 mm
- net Net-(D401-Pad2): track 0.00 -> 13.4 mm
- net Net-(C602-Pad1): track 0.00 -> 13.2 mm
- net Net-(C601-Pad1): track 0.00 -> 11.9 mm
- net /Pca/strip4_w: track 0.00 -> 11.9 mm
- net /Pca/strip1_r: track 0.00 -> 11.3 mm
- net /Pca/strip1_g: track 0.00 -> 11.1 mm
- net /Pca/strip4_b: track 0.00 -> 10.6 mm
- net /Microcontroller/addr3: track 0.00 -> 9.76 mm
- net /Pca/strip4_g: track 0.00 -> 9.65 mm
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
Commit message: Routing...
Parts:
- removed C602: 1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
- removed C604, C605: 0.1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
- removed C606: 4.7uF/16V, Capacitor_Tantalum_SMD:CP_EIA-6032-28_Kemet-C_Pad2.25x2.35mm_HandSolder
- removed R204: 100R/1W, Resistor_SMD:R_1812_4532Metric_Pad1.30x3.40mm_HandSolder
- removed R606: 1k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
- removed R607, R608: 10k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
- removed R609: 100, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
- removed TP602: pwm2, AmbientLight:TestPoint_Pad_D1.0mm
- removed TP604: a2, AmbientLight:TestPoint_Pad_D1.0mm
- removed TP606: ao2, AmbientLight:TestPoint_Pad_D1.0mm
- removed U601: LM393, Package_SO:SOIC-8_3.9x4.9mm_P1.27mm
- added C201: 0.1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (169.5, 67.9)
- added C202: 1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (162.9, 72.8)
- added C203: 0.1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (174.4, 67.9)
- added C204: 0.1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (167.7, 71.1)
- added C207: 0.1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (162.9, 75.8)
- added C208: 10uF/10V, Capacitor_Tantalum_SMD:CP_EIA-3216-18_Kemet-A_Pad1.58x1.35mm_HandSolder, F.Cu at (164.1, 68.0)
- added C401: 0.1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (125.8, 79.6)
- added C402: 0.1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (125.8, 74.6)
- added C403: 0.1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (143.8, 67.9)
- added C404: 22pF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (130.6, 79.6)
- added C405: 22pF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (125.8, 82.6)
- added C501: 0.1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (119.2, 89.1)
- added C701: 4.7uF/16V, Capacitor_Tantalum_SMD:CP_EIA-6032-28_Kemet-C_Pad2.25x2.35mm_HandSolder, F.Cu at (215.5, 113.0)
- added C702: 0.1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (213.5, 116.0)
- added D701: 4V7, Diode_SMD:D_1206_3216Metric_Pad1.42x1.75mm_HandSolder, F.Cu at (204.2, 134.1)
- added D702: Blue, LED_SMD:LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder, F.Cu at (186.3, 137.0)
- added J401: AVR-ISP-6, AmbientLight:ISP_P1.27mm_single_row, F.Cu at (119.0, 74.7)
- added R201: 10R, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (162.9, 78.8)
- added R202: R001/2W, Resistor_SMD:R_2512_6332Metric_Pad1.40x3.35mm_HandSolder, F.Cu at (156.6, 68.9)
- added R203: 10R, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (167.7, 74.1)
- added R401: 4k7, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (130.6, 82.6)
- added R402: 10k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (135.4, 79.6)
- added R403: 4k7, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (143.8, 73.9)
- added R701: 10k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (201.0, 133.6)
- added R702: 15k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (201.0, 135.6)
- added R703: 18k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (201.0, 131.6)
- added R704: 10k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (204.2, 129.7)
- added R705: 150k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (201.0, 129.5)
- added R706: 10k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (187.3, 134.1)
- added R707: 10k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (185.3, 134.1)
- added R708: 100, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (217.4, 116.0)
- added SW401: reset, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (135.4, 82.5)
- added TP202: +12V, AmbientLight:TestPoint_Pad_D1.0mm, F.Cu at (171.6, 71.0)
- added TP203: +5V, AmbientLight:TestPoint_Pad_D1.0mm, F.Cu at (166.8, 77.1)
- added TP401: dbg1, AmbientLight:TestPoint_Pad_D1.0mm, F.Cu at (139.3, 79.6)
- added TP402: dbg2, AmbientLight:TestPoint_Pad_D1.0mm, F.Cu at (142.9, 76.9)
- added TP403: scl, AmbientLight:TestPoint_Pad_D1.0mm, F.Cu at (139.3, 82.7)
- added TP404: ~reset~, AmbientLight:TestPoint_Pad_D1.0mm, F.Cu at (142.3, 79.9)
- added TP405: ~button~, AmbientLight:TestPoint_Pad_D1.0mm, F.Cu at (146.0, 76.9)
- added TP406: sda, AmbientLight:TestPoint_Pad_D1.0mm, F.Cu at (142.3, 83.0)
- added TP501: ~pca_oe~, AmbientLight:TestPoint_Pad_D1.0mm, F.Cu at (123.1, 89.1)
- added TP701: BO, AmbientLight:TestPoint_Pad_D1.0mm, F.Cu at (189.2, 137.2)
- added U201: INA219AxD, Package_SO:SOIC-8_3.9x4.9mm_P1.27mm, F.Cu at (156.3, 74.6)
- added U401: ATmega48PV-10AU-arduino, Package_QFP:TQFP-32_7x7mm_P0.8mm, F.Cu at (135.6, 72.3)
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Connections:
- C205 pad 1: Net-(C205-Pad1) -> +12V
- C206 pad 2: Net-(C205-Pad1) -> +12V
- J601 pad 2: Net-(C604-Pad1) -> GND
- R602 pad 1: Net-(C602-Pad1) -> /Pca/~oe~
- R602 pad 2: /0-10V/pwm2 -> /Brown-out/~Brown_out~
- U202 pad 3: Net-(C205-Pad1) -> +12V
Routing:
- net GNDPWR: track 2.67 -> 54.3 mm
- net Net-(C604-Pad1): track 28.7 -> 0.00 mm
- net /Brown-out/~Brown_out~: track 0.00 -> 27.6 mm
- net Net-(C603-Pad1): track 32.2 -> 11.1 mm
- net Net-(R703-Pad2): track 0.00 -> 20.0 mm
- net +12V: track 0.00 -> 18.9 mm
- net +12VA: track 26.5 -> 8.38 mm
- net Net-(C602-Pad1): track 13.2 -> 0.00 mm
- net GND: track 150.3 -> 137.4 mm, vias 2 -> 1
- net Net-(R701-Pad2): track 0.00 -> 12.4 mm
- net Net-(C601-Pad1): track 11.9 -> 0.00 mm
- net Net-(C205-Pad1): track 9.38 -> 0.00 mm
- net /Pca/strip4_w_out: track 0.00 -> 7.81 mm
- net /Pca/strip4_b_out: track 0.00 -> 6.26 mm
- net /Pca/strip4_r_out: track 0.00 -> 5.55 mm
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