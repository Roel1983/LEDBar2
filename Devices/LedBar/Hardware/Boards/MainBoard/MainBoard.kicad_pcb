File: Devices/LedBar/Hardware/Boards/MainBoard/MainBoard.kicad_pcb (KiCad board)
At the start: 2 copper layers, 120 x 24 mm, 116 parts, among them J201 12VDC/5A, J301 RS485, J401 AVR-ISP-6, J501 Left, J502 Center, J503 Right, J601 0-10V(1), Q501 Si2302DS, Q502 Si2302DS, Q503 Si2302DS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

Commit message: Added RGBW-wire-solder-pads, removed ground-tie, routing...
Parts:
- removed NT201: Net-Tie_2, NetTie:NetTie-2_THT_Pad0.3mm
- J501: footprint Connector_PinHeader_2.00mm:PinHeader_1x05_P2.00mm_Vertical -> AmbientLight:RGBW-wire-solder-pads-L
- J503: footprint Connector_PinHeader_2.00mm:PinHeader_1x05_P2.00mm_Vertical -> AmbientLight:RGBW-wire-solder-pads-R
- moved J501 13.6 mm to (195.1, 105.3)
- moved C505 6.40 mm to (165.0, 104.0)
- moved C504 6.39 mm to (165.0, 106.4)
- moved Q504 6.10 mm to (161.8, 113.0)
- moved Q508 6.10 mm to (160.8, 108.5)
- moved Q512 6.10 mm to (160.3, 116.7)
- moved Q516 6.10 mm to (160.3, 120.4)
- moved J503 4.70 mm to (155.6, 105.3)
- moved Q505 4.67 mm to (187.3, 108.5)
- moved Q506 3.64 mm to (178.9, 108.5)
- moved Q507 3.59 mm to (169.0, 108.5)
- moved Q501 3.33 mm to (186.3, 113.0), turned to 0 degrees
- moved Q502 3.21 mm to (180.0, 113.0), turned to 180 degrees
- moved Q503 2.69 mm to (168.1, 113.0), turned to 0 degrees
- moved Q515 2.41 mm to (170.1, 120.4)
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Connections:
- C201 pad 2: GNDPWR -> GND
- C203 pad 2: GNDPWR -> GND
- C502 pad 2: GNDPWR -> GND
- C503 pad 2: GNDPWR -> GND
- C504 pad 2: GNDPWR -> GND
- C505 pad 2: GNDPWR -> GND
- D201 pad 2: GNDPWR -> GND
- J201 pad 1: GNDPWR -> GND
- Q501 pad 2: GNDPWR -> GND
- Q502 pad 2: GNDPWR -> GND
- Q503 pad 2: GNDPWR -> GND
- Q504 pad 2: GNDPWR -> GND
- Q505 pad 2: GNDPWR -> GND
- Q506 pad 2: GNDPWR -> GND
- Q507 pad 2: GNDPWR -> GND
- Q508 pad 2: GNDPWR -> GND
- Q509 pad 2: GNDPWR -> GND
- Q510 pad 2: GNDPWR -> GND
- Q511 pad 2: GNDPWR -> GND
- Q512 pad 2: GNDPWR -> GND
- Q513 pad 2: GNDPWR -> GND
- Q514 pad 2: GNDPWR -> GND
- Q515 pad 2: GNDPWR -> GND
- Q516 pad 2: GNDPWR -> GND
- TP201 pad 1: GNDPWR -> GND
Routing:
- net GND: track 137.4 -> 370.2 mm
- net GNDPWR: track 54.3 -> 0.00 mm
- net +12V: track 18.9 -> 53.8 mm
- net /Pca/strip2_w_out: track 0.00 -> 6.41 mm
- net /Pca/strip3_w_out: track 0.00 -> 6.20 mm
- net /Pca/strip2_b_out: track 0.00 -> 5.75 mm
- net /Pca/strip3_b_out: track 0.00 -> 5.49 mm
- net /Pca/strip3_r_out: track 0.00 -> 4.77 mm
- net /Pca/strip3_g_out: track 0.00 -> 4.71 mm
- net /Pca/strip2_g_out: track 0.00 -> 4.44 mm
- net /Pca/strip2_r_out: track 0.00 -> 4.21 mm
- net /Pca/strip4_b_out: track 6.26 -> 9.24 mm
- net /Pca/strip4_g_out: track 4.90 -> 6.30 mm
- net /Pca/strip4_w_out: track 7.81 -> 8.64 mm
- net /Pca/strip4_r_out: track 5.55 -> 6.37 mm
Other:
- board text added: "TODO: move over FETS"
- board text added: "TODO: redo but than with 0.25mm GND in between"

Commit message: Routed FETs
Parts:
- moved J501 2.16 mm to (192.9, 105.3)
- moved J503 0.13 mm to (155.4, 105.3)
Routing:
- net GND: track 370.2 -> 420.2 mm
- net +12V: track 53.8 -> 65.1 mm
- net /Pca/strip1_w_out: track 0.00 -> 9.89 mm
- net /Pca/strip1_r_out: track 0.00 -> 8.61 mm
- net /Pca/strip1_b_out: track 0.00 -> 8.33 mm
- net /Pca/strip1_g_out: track 0.00 -> 5.74 mm
- net /Pca/strip4_r_out: track 6.37 -> 7.10 mm
- net /Pca/strip1_g: track 11.1 -> 11.7 mm
Other:
- board text removed: "TODO: redo but than with 0.25mm GND in between"

Commit message: FETs routed
Parts:
- removed C201, C203, C204, C207, C401, C402, C403, C501: 0.1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
- removed C202: 1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
- removed C208: 10uF/10V, Capacitor_Tantalum_SMD:CP_EIA-3216-18_Kemet-A_Pad1.58x1.35mm_HandSolder
- removed C404, C405: 22pF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
- removed J401: AVR-ISP-6, AmbientLight:ISP_P1.27mm_single_row
- removed R201, R203: 10R, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
- removed R202: R001/2W, Resistor_SMD:R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
- removed R401, R403: 4k7, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
- removed R402, R602: 10k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
- removed SW401: reset, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
- removed TP202: +12V, AmbientLight:TestPoint_Pad_D1.0mm
- removed TP203: +5V, AmbientLight:TestPoint_Pad_D1.0mm
- removed TP401: dbg1, AmbientLight:TestPoint_Pad_D1.0mm
- removed TP402: dbg2, AmbientLight:TestPoint_Pad_D1.0mm
- removed TP403: scl, AmbientLight:TestPoint_Pad_D1.0mm
- removed TP404: ~reset~, AmbientLight:TestPoint_Pad_D1.0mm
- removed TP405: ~button~, AmbientLight:TestPoint_Pad_D1.0mm
- removed TP406: sda, AmbientLight:TestPoint_Pad_D1.0mm
- removed U201: INA219AxD, Package_SO:SOIC-8_3.9x4.9mm_P1.27mm
- removed U401: ATmega48PV-10AU-arduino, Package_QFP:TQFP-32_7x7mm_P0.8mm
- removed Y401: 14.7456Mhz, Crystal:Crystal_HC49-U_Vertical
- moved TP501 54.8 mm to (158.4, 131.1)
- moved U501 14.4 mm to (156.6, 117.2)
- moved Q516 1.91 mm to (158.4, 120.4)
Routing:
- net GND: track 420.2 -> 654.6 mm, vias 1 -> 9
- net /Pca/strip2_g: track 3.71 -> 36.7 mm, vias 0 -> 1
- net /Pca/strip1_g: track 11.7 -> 43.0 mm, vias 0 -> 1
- net /Pca/strip1_r: track 11.3 -> 39.7 mm, vias 0 -> 1
- net /Pca/strip2_r: track 4.69 -> 30.0 mm, vias 0 -> 1
- net /Pca/strip1_b: track 9.61 -> 33.2 mm, vias 0 -> 1
- net /Pca/strip2_b: track 2.78 -> 25.9 mm, vias 0 -> 1
- net /Pca/strip2_w: track 1.56 -> 21.4 mm, vias 0 -> 1
- net /Pca/strip1_w: track 9.15 -> 28.5 mm, vias 0 -> 1
- net /Pca/strip3_w: track 4.59 -> 16.9 mm, vias 0 -> 1
- net /Pca/strip3_g: track 5.48 -> 17.5 mm, vias 0 -> 1
- net /Pca/strip4_w: track 11.6 -> 22.2 mm, vias 0 -> 1
- net /Pca/strip3_r: track 4.86 -> 12.3 mm, vias 0 -> 1
- net /Pca/strip3_b: track 6.09 -> 12.6 mm, vias 0 -> 1
- net /Pca/strip4_b: track 10.6 -> 15.0 mm, vias 0 -> 1
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Other:
- board text removed: "TODO: move over FETS"

Commit message: Routing...
Parts:
- added C201: 0.1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (189.6, 84.5)
- added C202: 1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (174.2, 87.6)
- added C203: 0.1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (189.7, 90.8)
- added C204: 0.1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (171.2, 90.8)
- added C207: 0.1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, B.Cu at (125.0, 103.7)
- added C208: 10uF/10V, Capacitor_Tantalum_SMD:CP_EIA-3216-18_Kemet-A_Pad1.58x1.35mm_HandSolder, B.Cu at (113.9, 105.2)
- added C401: 0.1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (147.1, 75.3)
- added C402: 0.1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (134.9, 90.0)
- added C403: 0.1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (147.1, 78.3)
- added C404: 22pF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (139.7, 90.0)
- added C405: 22pF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (142.8, 81.3)
- added C501: 0.1uF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (150.4, 119.2)
- added J401: AVR-ISP-6, AmbientLight:ISP_P1.27mm_single_row, F.Cu at (136.1, 80.6)
- added R201: 10R, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (179.2, 85.0)
- added R202: R001/2W, Resistor_SMD:R_2512_6332Metric_Pad1.40x3.35mm_HandSolder, F.Cu at (184.7, 87.8)
- added R203: 10R, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (179.1, 90.4)
- added R401: 4k7, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (142.8, 84.3)
- added R402: 10k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (147.6, 81.3)
- added R403: 4k7, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (147.6, 84.3)
- added R602: 10k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (186.3, 140.6)
- added SW401: reset, Button_Switch_SMD:SW_SPST_CK_RS282G05A3, F.Cu at (139.2, 76.4)
- added TP202: +12V, AmbientLight:TestPoint_Pad_D1.0mm, F.Cu at (130.8, 108.1)
- added TP203: +5V, AmbientLight:TestPoint_Pad_D1.0mm, F.Cu at (113.9, 108.7)
- added TP401: dbg1, AmbientLight:TestPoint_Pad_D1.0mm, F.Cu at (151.0, 75.3)
- added TP402: dbg2, AmbientLight:TestPoint_Pad_D1.0mm, F.Cu at (143.7, 87.3)
- added TP403: scl, AmbientLight:TestPoint_Pad_D1.0mm, F.Cu at (158.9, 95.4)
- added TP404: ~reset~, AmbientLight:TestPoint_Pad_D1.0mm, F.Cu at (151.5, 78.4)
- added TP405: ~button~, AmbientLight:TestPoint_Pad_D1.0mm, F.Cu at (146.7, 87.3)
- added TP406: sda, AmbientLight:TestPoint_Pad_D1.0mm, F.Cu at (158.4, 92.6)
- added U201: INA219AxD, Package_SO:SOIC-8_3.9x4.9mm_P1.27mm, F.Cu at (166.0, 89.2)
- added U401: ATmega48PV-10AU-arduino, Package_QFP:TQFP-32_7x7mm_P0.8mm, B.Cu at (124.2, 90.3)
- added Y401: 14.7456Mhz, Crystal:Crystal_HC49-U_Vertical, F.Cu at (124.9, 77.1)
- C303, D201: moved to B.Cu
- moved TP501 26.2 mm to (182.8, 140.7), turned to 180 degrees
- moved J601 12.8 mm to (200.2, 103.4)
- moved C603 12.8 mm to (204.0, 103.6)
- moved C701 12.8 mm to (202.7, 113.0)
- moved C702 12.8 mm to (200.7, 116.0)
- moved R603 12.8 mm to (204.6, 118.0)
- moved R604 12.8 mm to (204.6, 120.0)
- moved R605 12.8 mm to (204.6, 122.0)
- moved R708 12.8 mm to (204.6, 116.0)
- moved TP605 12.8 mm to (202.9, 101.6)
- moved U701 12.8 mm to (198.9, 120.3)
- moved TP303 7.27 mm to (110.4, 110.6)
- moved C303 6.53 mm to (119.3, 109.5), turned to 0 degrees
- moved C205 5.08 mm to (127.9, 105.5)
- moved C206 3.94 mm to (125.0, 107.4)
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Connections:
- net Net-(D301-Pad1) renamed /RS485/B
- net Net-(D301-Pad2) renamed /RS485/A
Routing:
- net GND_iso: track 71.0 -> 8.86 mm, vias 0 -> 3
- net GND: track 654.6 -> 606.2 mm, vias 9 -> 13
- net Net-(F201-Pad2): track 0.00 -> 10.2 mm
- net +5V: track 31.8 -> 38.1 mm
- net Net-(C201-Pad1): track 0.00 -> 5.30 mm
- net +5V_iso: track 18.4 -> 14.0 mm, vias 0 -> 1
- net /RS485/B: track 8.83 -> 11.4 mm
- net Net-(R301-Pad2): track 4.56 -> 6.85 mm
- net /RS485/A: track 12.6 -> 13.8 mm
- net +12V: track 65.4 -> 66.4 mm
- net Net-(R302-Pad2): track 5.20 -> 5.84 mm
- added copper zone on B.Cu, net GND
- added copper zone on F.Cu, net GND
- added copper zone on B.Cu, net GND_iso
- added copper zone on F.Cu, net GND_iso
Other:
- board text added: "Move 2x7 connector to correct location!!!"
