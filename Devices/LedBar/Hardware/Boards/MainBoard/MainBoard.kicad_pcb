# Repository Roel1983/LEDBar2

## KiCad design Devices/LedBar/Hardware/Boards/MainBoard/MainBoard.kicad_pcb

Parts:
C201, C203, C204, C206, C207: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C202: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C205: 10uF/16V; CP_EIA-6032-28_Kemet-C_Pad2.25x2.35mm_HandSolder
C208: 10uF/10V; CP_EIA-3216-18_Kemet-A_Pad1.58x1.35mm_HandSolder
D201: SMBJ15A; D_SMB_Handsoldering
F201: Max. 5A F; Fuseholder_Cylinder-5x20mm_BLX_A_Horizontal
J201: 12VDC/5A; 15EDGRC-3.81-2P
R201, R203: 10R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R202: R001/2W; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
TP201, TP204: gnd; TestPoint_Pad_D1.0mm
TP202: +12V; TestPoint_Pad_D1.0mm
TP203: +5V; TestPoint_Pad_D1.0mm
U201: INA219AxD; SOIC-8_3.9x4.9mm_P1.27mm
U202: AMS1117-5.0; SOT-223-3_TabPin2

Connections:
+5V: C204.2, C207.1, C208.1, TP203.1, U201.1 (A1), U201.5 (VS), U202.2 (VO); also elsewhere on the board
+12V: C203.1, R202.1, R203.1, TP202.1; also elsewhere on the board
/Microcontroller/scl: U201.4 (SCL); also elsewhere on the board
/Microcontroller/sda: U201.3 (SDA); also elsewhere on the board
GND: C201.2, C203.2, C204.1, C205.2, C206.1, C207.2, C208.2, D201.2 (A), J201.1, TP201.1, TP204.1, U201.2 (A0), U201.6 (GND), U202.1 (GND); also elsewhere on the board
unnamed: C201.1, C205.1, C206.2, D201.1 (K), F201.1, R201.1, R202.2, U202.3 (VI)
unnamed: C202.1, R203.2, U201.7 (IN-)
unnamed: C202.2, R201.2, U201.8 (IN+)
unnamed: F201.2, J201.2

Parts:
C301, C304: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C302: 10uF; CP_EIA-3216-18_Kemet-A_Pad1.58x1.35mm_HandSolder
C303: 4.7uF; CP_EIA-3216-18_Kemet-A_Pad1.58x1.35mm_HandSolder
D301: PSM712; SOT-23_Handsoldering
J301: RS485; 15EDGRC-3.5-3P
R301, R302: 120; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R303: 56; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
TP301: B; TestPoint_Pad_D1.0mm
TP302: A; TestPoint_Pad_D1.0mm
TP303: +5V_iso; TestPoint_Pad_D1.0mm
TP304: GND_iso; TestPoint_Pad_D1.0mm
TP305: txd; TestPoint_Pad_D1.0mm
TP306: rxd; TestPoint_Pad_D1.0mm
TP307: tx_en; TestPoint_Pad_D1.0mm
U301: ISO3082DW; SOIC-16W_7.5x10.3mm_P1.27mm
U302: B0505S-1W-SIP4; B0505S-1W

Connections:
+5V: C303.1, C304.1, U301.1 (Vcc1), U302.2 (5V+); also elsewhere on the board
+5V_iso: C301.2, C302.2, R303.1, TP303.1, U301.16 (Vcc2), U302.4 (5V+_iso)
/Microcontroller/rxd: TP306.1, U301.3 (R); also elsewhere on the board
/Microcontroller/tx_en: TP307.1, U301.4 (~RE), U301.5 (DE); also elsewhere on the board
/Microcontroller/txd: TP305.1, U301.6 (D); also elsewhere on the board
/RS485/A: D301.2 (A2), J301.2, R302.1, TP302.1
/RS485/B: D301.1 (A1), J301.3, R301.1, TP301.1
GND: C303.2, C304.2, U301.2 (GND1), U301.7 (GND1), U301.8 (GND1), U302.1 (GND); also elsewhere on the board
GND_iso: C301.1, C302.1, D301.3 (common), J301.1, R303.2, TP304.1, U301.9 (GND2), U301.10 (GND2), U301.15 (GND2), U302.3 (GND_iso)
unnamed: R301.2, U301.13 (B)
unnamed: R302.2, U301.12 (A)

Notes on the sheet:
Resistor added to make sure: The B0505S has a minimum load of 10% of its maximum load.

Parts:
C501, C502, C504: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C503, C505: 1000uF/16V; CP_Radial_D10.0mm_P5.00mm
J501: Left; RGBW-wire-solder-pads-L
J502: Center; PinSocket_2x07_P2.00mm_Vertical
J503: Right; RGBW-wire-solder-pads-R
Q501, Q502, Q503, Q504, Q505, Q506, Q507, Q508, Q509, Q510, Q511, Q512, Q513, Q514, Q515, Q516: Si2302DS; SOT-23_Handsoldering
TP501: ~pca_oe~; TestPoint_Pad_D1.0mm
TP502: strip1_w; TestPoint_Pad_D1.0mm
TP503: strip1_w_out; TestPoint_Pad_D1.0mm
TP504: gnd; TestPoint_Pad_D1.0mm
U501: PCA9685PW; TSSOP-28_4.4x9.7mm_P0.65mm

Connections:
+5V: C501.2, U501.28 (VDD); also elsewhere on the board
+12V: C502.1, C503.1, C504.1, C505.1, J501.1, J502.1, J502.2, J502.3, J502.4, J503.1; also elsewhere on the board
/Microcontroller/scl: U501.26 (SCL); also elsewhere on the board
/Microcontroller/sda: U501.27 (SDA); also elsewhere on the board
/Microcontroller/~button~: J502.14; also elsewhere on the board
/Pca/strip1_b: Q509.1 (G), U501.8 (LED2)
/Pca/strip1_b_out: J501.4, Q509.3 (D)
/Pca/strip1_g: Q505.1 (G), U501.7 (LED1)
/Pca/strip1_g_out: J501.2, Q505.3 (D)
/Pca/strip1_r: Q501.1 (G), U501.6 (LED0)
/Pca/strip1_r_out: J501.3, Q501.3 (D)
/Pca/strip1_w: Q513.1 (G), TP502.1, U501.9 (LED3)
/Pca/strip1_w_out: J501.5, Q513.3 (D), TP503.1
/Pca/strip2_b: Q510.1 (G), U501.12 (LED6)
/Pca/strip2_b_out: J502.10, Q510.3 (D)
/Pca/strip2_g: Q506.1 (G), U501.11 (LED5)
/Pca/strip2_g_out: J502.6, Q506.3 (D)
/Pca/strip2_r: Q502.1 (G), U501.10 (LED4)
/Pca/strip2_r_out: J502.8, Q502.3 (D)
/Pca/strip2_w: Q514.1 (G), U501.13 (LED7)
/Pca/strip2_w_out: J502.12, Q514.3 (D)
/Pca/strip3_b: Q511.1 (G), U501.17 (LED10)
/Pca/strip3_b_out: J502.9, Q511.3 (D)
/Pca/strip3_g: Q507.1 (G), U501.16 (LED9)
/Pca/strip3_g_out: J502.5, Q507.3 (D)
/Pca/strip3_r: Q503.1 (G), U501.15 (LED8)
/Pca/strip3_r_out: J502.7, Q503.3 (D)
/Pca/strip3_w: Q515.1 (G), U501.18 (LED11)
/Pca/strip3_w_out: J502.11, Q515.3 (D)
/Pca/strip4_b: Q512.1 (G), U501.21 (LED14)
/Pca/strip4_b_out: J503.4, Q512.3 (D)
/Pca/strip4_g: Q508.1 (G), U501.20 (LED13)
/Pca/strip4_g_out: J503.2, Q508.3 (D)
/Pca/strip4_r: Q504.1 (G), U501.19 (LED12)
/Pca/strip4_r_out: J503.3, Q504.3 (D)
/Pca/strip4_w: Q516.1 (G), U501.22 (LED15)
/Pca/strip4_w_out: J503.5, Q516.3 (D)
/Pca/~oe~: TP501.1, U501.23 (~OE); also elsewhere on the board
GND: C501.1, C502.2, C503.2, C504.2, C505.2, J502.13, Q501.2 (S), Q502.2 (S), Q503.2 (S), Q504.2 (S), Q505.2 (S), Q506.2 (S), Q507.2 (S), Q508.2 (S), Q509.2 (S), Q510.2 (S), Q511.2 (S), Q512.2 (S), Q513.2 (S), Q514.2 (S), Q515.2 (S), Q516.2 (S), TP504.1, U501.1 (A0), U501.2 (A1), U501.3 (A2), U501.4 (A3), U501.5 (A4), U501.14 (VSS), U501.24 (A5), U501.25 (EXTCLK); also elsewhere on the board

Parts:
C601: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C603: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
J601: 0-10V(1); 15EDGRC-3.5-2P
R601: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R603: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R604, R605: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TP601: pwm1; TestPoint_Pad_D1.0mm
TP603: a1; TestPoint_Pad_D1.0mm
TP605: ao1; TestPoint_Pad_D1.0mm
U701: LM393; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+12VA: R603.1; also elsewhere on the board
/0-10V/a1: C601.1, R601.1, TP603.1, U701.5 (+)
/0-10V/pwm1: R601.2, TP601.1; also elsewhere on the board
GND: C601.2, C603.2, J601.2, R605.2; also elsewhere on the board
unnamed: C603.1, J601.1, R603.2, R604.1, TP605.1, U701.7
unnamed: R604.2, R605.1, U701.6 (_)

Parts:
C401, C402, C403: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C404, C405: 22pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D401: Green; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D402: Yellow; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D403: Orange; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D404: Red; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J401: AVR-ISP-6; ISP_P1.27mm_single_row
JP401, JP402, JP403, JP404, JP405: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
R401, R403: 4k7; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R402, R602: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
RN401: 10k; R_Array_Concave_4x0603
SW401: reset; SW_SPST_CK_RS282G05A3
TP401: dbg1; TestPoint_Pad_D1.0mm
TP402: dbg2; TestPoint_Pad_D1.0mm
TP403: scl; TestPoint_Pad_D1.0mm
TP404: ~reset~; TestPoint_Pad_D1.0mm
TP405: ~button~; TestPoint_Pad_D1.0mm
TP406: sda; TestPoint_Pad_D1.0mm
TP407, TP408: gnd; TestPoint_Pad_D1.0mm
U401: ATmega48PV-10AU-arduino; TQFP-32_7x7mm_P0.8mm
Y401: 14.7456Mhz; Crystal_HC49-U_Vertical

Connections:
+5V: C402.1, C403.2, J401.2 (VCC), R401.1, R402.1, R403.1, U401.4 (VCC), U401.6 (VCC), U401.18 (AVCC); also elsewhere on the board
/0-10V/pwm1: U401.9 (PD5(5)); also elsewhere on the board
/Brown-out/~Brown_out~: R602.1, U401.1 (PD3(3)); also elsewhere on the board
/Microcontroller/addr1: JP401.1 (A), U401.2 (PD4(4))
/Microcontroller/addr2: JP402.1 (A), U401.10 (PD6(6))
/Microcontroller/addr3: JP403.1 (A), U401.11 (PD7(7))
/Microcontroller/addr4: JP404.1 (A), U401.12 (PB0(8))
/Microcontroller/addr5: JP405.1 (A), U401.13 (PB1(9))
/Microcontroller/debug1: TP401.1, U401.24 (PC1(A1/15))
/Microcontroller/debug2: TP402.1, U401.25 (PC2(A2/16))
/Microcontroller/led1: RN401.8 (R1.2), U401.14 (PB2(10))
/Microcontroller/led2_mosi: J401.4 (MOSI), RN401.7 (R2.2), U401.15 (PB3(11))
/Microcontroller/led3_sck: J401.3 (SCK), RN401.6 (R3.2), U401.17 (PB5(13))
/Microcontroller/led4_miso: J401.1 (MISO), RN401.5 (R4.2), U401.16 (PB4(12))
/Microcontroller/rxd: U401.30 (PD0(0)); also elsewhere on the board
/Microcontroller/scl: R401.2, TP403.1, U401.28 (PC5(A5/19)); also elsewhere on the board
/Microcontroller/sda: R403.2, TP406.1, U401.27 (PC4(A4/18)); also elsewhere on the board
/Microcontroller/tx_en: U401.26 (PC3(A3/17)); also elsewhere on the board
/Microcontroller/txd: U401.31 (PD1(1)); also elsewhere on the board
/Microcontroller/~button~: TP405.1, U401.23 (PC0(A0/14)); also elsewhere on the board
/Microcontroller/~reset~: J401.5 (~RST), R402.2, SW401.2, TP404.1, U401.29 (~RESET~/PC6(22))
/Pca/~oe~: R602.2, U401.32 (PD2(2)); also elsewhere on the board
GND: C401.1, C402.2, C403.1, C404.1, C405.1, D401.1 (K), D402.1 (K), D403.1 (K), D404.1 (K), J401.6 (GND), JP401.2 (B), JP402.2 (B), JP403.2 (B), JP404.2 (B), JP405.2 (B), SW401.1, TP407.1, TP408.1, U401.3 (GND), U401.5 (GND), U401.21 (GND); also elsewhere on the board
unnamed: C401.2, U401.20 (AREF)
unnamed: C404.2, U401.7 (XTAL1/PB6(20)), Y401.2
unnamed: C405.2, U401.8 (XTAL2/PB7(21)), Y401.1
unnamed: D401.2 (A), RN401.1 (R1.1)
unnamed: D402.2 (A), RN401.2 (R2.1)
unnamed: D403.2 (A), RN401.3 (R3.1)
unnamed: D404.2 (A), RN401.4 (R4.1)

Parts:
C701: 4.7uF/16V; CP_EIA-6032-28_Kemet-C_Pad2.25x2.35mm_HandSolder
C702: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D701: 4V7; D_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D702: Blue; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R701, R704, R706, R707: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R702: 15k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R703: 18k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R705: 150k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R708: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TP701: BO; TestPoint_Pad_D1.0mm
U701: LM393; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5V: R706.1, R707.1; also elsewhere on the board
+12V: R708.2; also elsewhere on the board
+12VA: C701.1, C702.1, R701.1, R703.1, R708.1, U701.8 (V+); also elsewhere on the board
/Brown-out/~Brown_out~: D702.1 (K), R705.1, R706.2, TP701.1, U701.1; also elsewhere on the board
GND: C701.2, C702.2, D701.2 (A), R702.2, U701.4 (V-); also elsewhere on the board
unnamed: D701.1 (K), R704.2
unnamed: D702.2 (A), R707.2
unnamed: R701.2, R702.1, U701.2 (-)
unnamed: R703.2, R704.1, R705.2, U701.3 (+)

Board: 2 copper layers, 97.2 x 24.0 mm, 122 parts (77 on the bottom side), 81 nets.

## Commit log

2021-04-25 Inittial commit
2021-04-25 Added Power schematic sheet
2021-04-25 Moved files around
2021-04-25 Added connector 15EDG-3.81-2P
2021-04-25 Added footprint for Fuseholder
2021-04-26 Added RS485 schematic sheet
2021-04-26 Added connector footprints
2021-04-26 Added footprint for B0505S-1W
2021-04-26 Added testpoints for RS485
2021-04-27 Added different footprints for connectors
2021-04-27 Added Board outline
2021-04-29 Added Microcontroller schematic
2021-04-29 Added PCA schematic
2021-04-30 Added 0-10V schematic
2021-04-30 Renamed CenterBoard to MainBoard
2021-04-30 Fixed missing wire and rotated connector
2021-04-30 Placed components for RS485
2021-04-30 Fixed using wrong resistor network symbol
2021-05-01 Placing and routing
2021-05-02 Added Brown-out detection
2021-05-02 Moved brown-out to it own sheet
2021-05-02 Added footprints for brown-out circuit
2021-05-02 Routing...
2021-05-02 Added RGBW-wire-solder-pads, removed ground-tie, routing...
2021-05-03 Routed FETs
2021-05-03 FETs routed
2021-05-04 Routed 0-10V and brownout circuits
2021-05-08 Routing
2021-05-13 Adds Bootloader
2021-05-13 Fixed testpoint footprint
2021-05-24 Added delay between switching from receiving to sending to give host time enought to switch to listening
2021-05-27 cleaning layout
2021-06-10 Added Rtc
2021-07-01 Removed RTC and EEPROM all routed
2021-07-06 Work in progress
2021-09-27 Added datasheet
2021-09-27 Added resistor to make sure the B0505S has a minimum load
2021-09-27 Added resistor on PCB, updated coper-plane and updated silkscreen
